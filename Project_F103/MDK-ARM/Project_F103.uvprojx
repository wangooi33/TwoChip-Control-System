# Keil uVision project Project_F103.uvprojx, settings and files
target Project_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project_F103 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSW/IIC;../BSW/SCCB;../BSW/Delay;../ASW/Check;../ASW/IAP;../ASW/Task_Manage;../Component/AT24Cxx;../Component/LCD;../Component/LF0038;../Component/NM25Qxx;../Component/OV7725;../Component/RGB;../Component/TJC;..\Component\FreeRTOS\include;..\Component\FreeRTOS\portable\RVDS\ARM_CM3;..\Component\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fsmc.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSW/IIC
    ../BSW/IIC/: iic.c
  group BSW/SCCB
    ../BSW/SCCB/: sccb.c
  group BSW/Delay
    ../BSW/Delay/: delay.c
  group ASW/Check
    ../ASW/Check/: check.c
  group ASW/IAP
    ../ASW/IAP/: IAP.c
  group ASW/Task_Manage
    ../ASW/Task_Manage/: task_manage.c
  group Component/AT24Cxx
    ../Component/AT24Cxx/: at24cxx.c
  group Component/NM24Qxx
    ../Component/NM25Qxx/: nm25qxx.c
  group Component/RGB
    ../Component/RGB/: rgb_led.c
  group Component/OV7725
    ../Component/OV7725/: ov7725.c ov7725_Reg.c
  group Component/LCD
    ../Component/LCD/: lcd.c lcd_cfg.c
  group Component/LF0038
    ../Component/LF0038/: lf0038.c
  group Component/TJC
    ../Component/TJC/: tjc.c
  group FreeRTOS_Config
    ../Component/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS_Code
    ../Component/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ../Component/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Component/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
